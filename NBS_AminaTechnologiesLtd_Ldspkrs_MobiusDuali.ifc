Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-08-25T09:29:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Aug 25 09:29:40 2020* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{204DAB0D-DBC4-4129-B8BF-E7C2D70D5CB7}\ifc* Database version: 5507* Database creation date: Tue Aug 25 09:29:27 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Aug 25 09:29:39 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Aug 25 09:29:39 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: MobiusDuali, NBS_AminaTechnologiesLtd_Ldspkrs_MobiusDuali:MobiusDuali:307560
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: Pr_70_75_06_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AminaTechnologiesLtd_Loudspeakers_MobiusDuali; ManufacturerName: Amina Technologies Ltd; ManufacturerURL: https:/​/​uk.aminasound.com/​; NBSCertification: www.nationalbimlibrary.com/cert/l0xg1htu; NBSDescription: Loudspeakers; NBSReference: 90-70-10/435; ProductInformation: https://uk.aminasound.com/file-directory/product/loudspeakers/mobius/datasheet/MobiusDual_Datasheet.pdf; Revision: n/a; Uniclass2015Title: Loudspeakers; Uniclass2015Code: Pr_70_75_06_50; Uniclass2015Version: Products v1.18; Version: 1
Type - NBS_Data - LoudspeakerSensitivity: 83dB SPL (at 1m / 2.83Vrms, both channels driven, with 2mm plaster skim); RatedImpedance: 2 x 6 ohm; PowerHandlingContinuous: 2 x 30W RMS (2 x 60W Peak); Dispersion: 180° x 180° at specified frequency range; EnclosureFormat: Integrated; CableConnectionsType: Two pair blue butt-splice crimp terminals; CableConnectionsCapacity: 14–16 AWG; Weight: 2.1 kg; EnclosureIngressProtectionMinimum: Sealed away from room with 2 mm of covering material and decorative layer; FixingRequirements: Backbox CV/SW345 or Mounting Blocks; InLineProtectionUnit: Two APUi30C, APU-RS8iC or APU-RS16iC; UseableFrequencyRange: 90Hz – 32kHz (±10 dB)
Type - Pset_AudioVisualApplianceTypeCommon - AudioVolume: n/a; MediaSource: n/a; Reference: n/a
Type - Pset_AudioVisualApplianceTypeSpeaker - FrequencyResponse: 105Hz – 29kHz (-6dB); Impedence: 2 x 6 ohm; SpeakerDriverSize: n/a; SpeakerMounting: WALL; SpeakerType: FULLRANGE
Type - IFC - IfcExportAs: IfcAudioVisualApplianceType; IfcExportType: SPEAKER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_75_06_50:Loudspeakers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: A single-panel stereo invisible loudspeaker, using the same OptiDrive, OptiDamping and Reduced Resonance Exciter technologies that are found in the Mobius Series invisible loudspeakers, this gives high quality dual-channel audio reproduction where there is insufficient space for a pair of speakers; DurationUnit: year; ExpectedLife: n/a; Features: Suitable for both commercial and residential applications, fully covered with 2 mm of almost any finishing material including wood, plaster, stone laminates, leather and more, completely invisible in application, exceptional dispersion, typically requiring two to four times fewer loudspeakers to cover the same space when compared to paper-cone based loudspeakers, beneficial in acoustically harsh spaces, ideal for aesthetically sensitive applications where stereo image (width) is not critical but sound quality and even dispersion are still required, and in rooms with insufficient space for a pair of speakers; Finish: n/a; Grade: n/a; Manufacturer: sales@aminasound.com; Material: n/a; ModelNumber: MobiusDual i; ModelReference: MobiusDual i; Name: Loudspeakers_MobiusDuali_AminaTechnologiesLtd; NominalHeight: 450 mm; NominalLength: 345 mm; NominalWidth: 35 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 450 x 345 x 35 mm; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer limited warranty; WarrantyDurationLabor: 0; WarrantyDurationParts: 10; WarrantyDurationUnit: year; WarrantyGuarantorLabor: Installer; WarrantyGuarantorParts: Amina Technologies Ltd
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_307560
Description: Flow; FlowDirection: SOURCEANDSINK
